#include "protocol.h"

#define UPDATE_TIMEOUT do{m_timeout_stamp = Systick_getMsTick();}while (0)

const uint8_t crc_table[256] = {
    0x00, 0x5e, 0xbc, 0xe2, 0x61, 0x3f, 0xdd, 0x83, 
    0xc2, 0x9c, 0x7e, 0x20, 0xa3, 0xfd, 0x1f, 0x41, 
    0x9d, 0xc3, 0x21, 0x7f, 0xfc, 0xa2, 0x40, 0x1e, 
    0x5f, 0x01, 0xe3, 0xbd, 0x3e, 0x60, 0x82, 0xdc, 
    0x23, 0x7d, 0x9f, 0xc1, 0x42, 0x1c, 0xfe, 0xa0, 
    0xe1, 0xbf, 0x5d, 0x03, 0x80, 0xde, 0x3c, 0x62, 
    0xbe, 0xe0, 0x02, 0x5c, 0xdf, 0x81, 0x63, 0x3d, 
    0x7c, 0x22, 0xc0, 0x9e, 0x1d, 0x43, 0xa1, 0xff, 
    0x46, 0x18, 0xfa, 0xa4, 0x27, 0x79, 0x9b, 0xc5, 
    0x84, 0xda, 0x38, 0x66, 0xe5, 0xbb, 0x59, 0x07, 
    0xdb, 0x85, 0x67, 0x39, 0xba, 0xe4, 0x06, 0x58, 
    0x19, 0x47, 0xa5, 0xfb, 0x78, 0x26, 0xc4, 0x9a, 
    0x65, 0x3b, 0xd9, 0x87, 0x04, 0x5a, 0xb8, 0xe6, 
    0xa7, 0xf9, 0x1b, 0x45, 0xc6, 0x98, 0x7a, 0x24, 
    0xf8, 0xa6, 0x44, 0x1a, 0x99, 0xc7, 0x25, 0x7b, 
    0x3a, 0x64, 0x86, 0xd8, 0x5b, 0x05, 0xe7, 0xb9, 
    0x8c, 0xd2, 0x30, 0x6e, 0xed, 0xb3, 0x51, 0x0f, 
    0x4e, 0x10, 0xf2, 0xac, 0x2f, 0x71, 0x93, 0xcd, 
    0x11, 0x4f, 0xad, 0xf3, 0x70, 0x2e, 0xcc, 0x92, 
    0xd3, 0x8d, 0x6f, 0x31, 0xb2, 0xec, 0x0e, 0x50, 
    0xaf, 0xf1, 0x13, 0x4d, 0xce, 0x90, 0x72, 0x2c, 
    0x6d, 0x33, 0xd1, 0x8f, 0x0c, 0x52, 0xb0, 0xee, 
    0x32, 0x6c, 0x8e, 0xd0, 0x53, 0x0d, 0xef, 0xb1, 
    0xf0, 0xae, 0x4c, 0x12, 0x91, 0xcf, 0x2d, 0x73, 
    0xca, 0x94, 0x76, 0x28, 0xab, 0xf5, 0x17, 0x49, 
    0x08, 0x56, 0xb4, 0xea, 0x69, 0x37, 0xd5, 0x8b, 
    0x57, 0x09, 0xeb, 0xb5, 0x36, 0x68, 0x8a, 0xd4, 
    0x95, 0xcb, 0x29, 0x77, 0xf4, 0xaa, 0x48, 0x16, 
    0xe9, 0xb7, 0x55, 0x0b, 0x88, 0xd6, 0x34, 0x6a, 
    0x2b, 0x75, 0x97, 0xc9, 0x4a, 0x14, 0xf6, 0xa8, 
    0x74, 0x2a, 0xc8, 0x96, 0x15, 0x4b, 0xa9, 0xf7, 
    0xb6, 0xe8, 0x0a, 0x54, 0xd7, 0x89, 0x6b, 0x35,
};

void do_crc(uint8_t* crc, uint8_t new_data) {
    *crc = crc_table[(*crc ^ new_data) & 0xff];
}

void DeviceProtocolRx::processCmdFrame(uint8_t rx_byte) {
    switch (m_state) {
        case (IDLE) : {
            m_data_index = 0;
            memset(&m_last_cmd_frame, 0, sizeof(m_last_cmd_frame));
            m_last_cmd_frame.addr_n_cmd = rx_byte;
            uint8_t cmd = m_last_cmd_frame.addr_n_cmd & CMD_MASK;
            if (cmd > (uint8_t)Cmd::NOP && cmd < (uint8_t)Cmd::SET_MODE) {
                m_state = CHECKSUM;
            }
            else {
                m_state = DATA;
            }
            do_crc(&m_last_cmd_frame.checksum, rx_byte);
            UPDATE_TIMEOUT;
            break;
        }
        case (DATA):
            m_data_buffer[m_data_index] = rx_byte;
            m_data_index++;
            do_crc(&m_last_cmd_frame.checksum, rx_byte);
            if (m_data_index > 3) {
                m_state = CHECKSUM;
                memcpy(m_last_cmd_frame.data, m_data_buffer, 4);
            }
            UPDATE_TIMEOUT;
            break;
        case (CHECKSUM): {
            bool crc_ok = (rx_byte == m_last_cmd_frame.checksum);
            bool addr_ok = ((m_last_cmd_frame.addr_n_cmd >> 5) == m_device_addr);

            if (addr_ok) {
                m_state = AWAITS_SEND;
                if (m_cmd_callback) {
                    uint8_t tag = m_last_cmd_frame.addr_n_cmd >> 5;
                    uint8_t cmd = m_last_cmd_frame.addr_n_cmd & CMD_MASK;
                    uint32_t data;
                    memcpy(&data, m_last_cmd_frame.data, sizeof(data));
                    m_cmd_callback(crc_ok, tag, cmd, data);
                }
            }
            else {
                m_state = IDLE;
            }
            UPDATE_TIMEOUT;
            break;
        }
        case (AWAITS_SEND):
        default:
            break;
    }
}

void DeviceProtocolRx::updateTimeoutState() {
    if (Systick_getMsTick() - m_timeout_stamp > 200) {
        m_state = IDLE;
    }
}

void DeviceProtocolTx::setTag(uint8_t tag) {
    m_tx_buffer[0] &= 0x1f; // clear the tag bits
    m_tx_buffer[0] |= (static_cast<uint8_t>(tag) & 0x07) << 5;
}

void DeviceProtocolTx::setType(DataFrameType type) {
    m_tx_buffer[0] &= 0xe0; // clear the type bits
    m_tx_buffer[0] |= static_cast<uint8_t>(type) & 0x1f;
    m_tx_len = 2;
}

void DeviceProtocolTx::setData(const uint8_t* data, int len) {
    memcpy(&m_tx_buffer[1], data, len);
    m_tx_len = len + 2;
}

int DeviceProtocolTx::getTxFrame(uint8_t* buffer) {
    uint8_t crc = 0;
    for (int i = 0; i < m_tx_len - 1; i++) {
        do_crc(&crc, m_tx_buffer[i]);
    }
    m_tx_buffer[m_tx_len - 1] = crc;
    // do_crc(&m_tx_buffer[m_tx_len - 1], m_tx_buffer[m_tx_len - 2]);

    memcpy(buffer, m_tx_buffer, m_tx_len);
    return m_tx_len;
}